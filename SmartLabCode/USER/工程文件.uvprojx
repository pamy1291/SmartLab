# Keil uVision project 工程文件.uvprojx, settings and files
target 工程 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程文件 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\HARDWARE\inc;..\CORE;..\STLIB\inc;..\HMAC\inc;..\HARDWARE\DHT11;..\HARDWARE\sys;..\HARDWARE\inc;..\DELAY\inc;..\HARDWARE\KEY4_4;..\HARDWARE\LED;..\HARDWARE\MQ2;..\HARDWARE\MLX90614;..\HARDWARE\OLED;..\HARDWARE\RFID;..\HARDWARE\SPI;..\HARDWARE\SYN6288;..\HARDWARE\usart
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/scr/: usart1.c stm32f10x_it.c usart2.c wifi.c mqtt.c timer3.c timer2.c iwdg.c dateup.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/sys/: sys.c
    ../HARDWARE/KEY4_4/: key4_4.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MLX90614/: mlx90614.c
    ../HARDWARE/MQ2/: mq2.c
    ../HARDWARE/OLED/: oled.c oled_zim.c
    ../HARDWARE/RFID/: rc522.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/SYN6288/: syn6288.c
    ../HARDWARE/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group STLIB
    ../STLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_iwdg.c stm32f10x_dma.c stm32f10x_spi.c
  group HMAC
    ../HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
  group DELAY
    ../DELAY/scr/: delay.c
